FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://ft6x06_ts.patch file://ft6x06_ts.cfg"
